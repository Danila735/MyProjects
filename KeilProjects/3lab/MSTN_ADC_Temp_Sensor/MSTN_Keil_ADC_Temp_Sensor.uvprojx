# Keil uVision project MSTN_Keil_ADC_Temp_Sensor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MSTN_Keil_ADC_Temp_Sensor
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.5
